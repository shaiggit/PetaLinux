SRC_URI += "file://user_2020-02-29-19-42-00.cfg \
            file://user_2020-03-05-22-03-00.cfg \
            file://user_2020-03-08-16-42-00.cfg \
            file://user_2020-03-16-21-07-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

